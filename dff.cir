* C:\Users\kesav\eSim-Workspace\dff\dff.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/24/20 10:29:36

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U12-Pad2_ Net-_U10-Pad2_ Net-_U10-Pad4_ Net-_U10-Pad3_ Net-_U3-Pad5_ ? d_dff
U8  Net-_U3-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad1_ ? d_dff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ ? d_dff
U6  Net-_U1-Pad2_ Net-_U6-Pad2_ Net-_U3-Pad5_ ? Net-_U6-Pad5_ ? d_dff
U9  Net-_U1-Pad2_ Net-_U11-Pad5_ Net-_U10-Pad1_ Net-_U11-Pad4_ Net-_U6-Pad2_ ? d_dff
U11  Net-_U1-Pad2_ Net-_U11-Pad2_ Net-_U10-Pad5_ Net-_U11-Pad4_ Net-_U11-Pad5_ ? d_dff
v1  clk GND pulse
U7  Net-_U6-Pad2_ Net-_U6-Pad5_ d8 d9 dac_bridge_2
U2  clk plot_v1
U4  d8 plot_v1
U12  GNDD Net-_U12-Pad2_ adc_bridge_1
U16  GND Net-_U16-Pad2_ adc_bridge_1
R1  d9 GND 1k
R2  d8 GND 1k
U13  clk Net-_U10-Pad2_ adc_bridge_1
U1  comp Net-_U1-Pad2_ adc_bridge_1
U17  rst plot_v1
v2  comp GND pulse
v3  rst GND pulse
U15  comp plot_v1
U18  d9 plot_v1
U14  rst Net-_U10-Pad4_ adc_bridge_1
U27  Net-_U10-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ ? Net-_U27-Pad5_ ? d_dff
U29  Net-_U27-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U29-Pad5_ ? d_dff
U31  Net-_U29-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U31-Pad5_ ? d_dff
U33  Net-_U31-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U33-Pad5_ ? d_dff
U35  Net-_U33-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U35-Pad5_ ? d_dff
U37  Net-_U35-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U37-Pad5_ ? d_dff
U39  Net-_U37-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U39-Pad5_ ? d_dff
U28  Net-_U1-Pad2_ Net-_U26-Pad6_ Net-_U27-Pad5_ Net-_U11-Pad4_ Net-_U11-Pad2_ ? d_dff
U30  Net-_U1-Pad2_ Net-_U26-Pad5_ Net-_U29-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad6_ ? d_dff
U32  Net-_U1-Pad2_ Net-_U26-Pad4_ Net-_U31-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad5_ ? d_dff
U34  Net-_U1-Pad2_ Net-_U26-Pad3_ Net-_U33-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad4_ ? d_dff
U36  Net-_U1-Pad2_ Net-_U26-Pad2_ Net-_U35-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad3_ ? d_dff
U38  Net-_U1-Pad2_ Net-_U26-Pad1_ Net-_U37-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad2_ ? d_dff
U40  Net-_U1-Pad2_ Net-_U40-Pad2_ Net-_U39-Pad5_ Net-_U11-Pad4_ Net-_U26-Pad1_ ? d_dff
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ Net-_U26-Pad3_ Net-_U26-Pad4_ Net-_U26-Pad5_ Net-_U26-Pad6_ Net-_U11-Pad2_ Net-_U11-Pad5_ d0 d1 d2 d3 d4 d5 d6 d7 dac_bridge_8
U25  d0 plot_v1
U24  d7 plot_v1
U22  d6 plot_v1
U20  d5 plot_v1
U19  d4 plot_v1
U5  d3 plot_v1
U21  d2 plot_v1
U23  d1 plot_v1
U41  Net-_U39-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U41-Pad5_ ? d_dff
U42  Net-_U16-Pad2_ Net-_U16-Pad2_ Net-_U41-Pad5_ Net-_U11-Pad4_ Net-_U40-Pad2_ ? d_dff

.end
