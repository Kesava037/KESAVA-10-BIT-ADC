* C:\Users\kesav\eSim-Workspace\adcsar\adcsar.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/18/20 19:42:12

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  in Net-_M1-Pad2_ out out eSim_MOS_N
M2  out Net-_M2-Pad2_ in out eSim_MOS_P
v2  Net-_M1-Pad2_ GND pulse
v1  in GND sine
X1  Net-_M1-Pad2_ Net-_M2-Pad2_ INVCMOS
M6  VDD Net-_M3-Pad1_ Net-_M6-Pad3_ VDD eSim_MOS_P
M9  VDD Net-_M6-Pad3_ Net-_M8-Pad1_ VDD eSim_MOS_P
M3  Net-_M3-Pad1_ out Net-_M3-Pad3_ Net-_M3-Pad3_ eSim_MOS_N
M7  Net-_M3-Pad3_ Net-_M14-Pad3_ Net-_M6-Pad3_ Net-_M6-Pad3_ eSim_MOS_N
M8  Net-_M8-Pad1_ Net-_M6-Pad3_ GND GND eSim_MOS_N
M5  Net-_M3-Pad3_ Net-_M1-Pad2_ GND GND eSim_MOS_N
M4  Net-_M3-Pad1_ Net-_M3-Pad1_ VDD VDD eSim_MOS_P
U2  GND Net-_U10-Pad2_ Net-_U10-Pad4_ ? Net-_U2-Pad5_ ? d_dff
U4  Net-_U2-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U4-Pad5_ ? d_dff
U7  Net-_U4-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad1_ ? d_dff
U3  Net-_M8-Pad1_ d2 Net-_U2-Pad5_ Net-_U12-Pad4_ d3 ? d_dff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ ? d_dff
U13  Net-_U10-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U13-Pad5_ ? d_dff
U6  Net-_M8-Pad1_ d1 Net-_U4-Pad5_ Net-_U12-Pad4_ d2 ? d_dff
U9  Net-_M8-Pad1_ d0 Net-_U10-Pad1_ Net-_U12-Pad4_ d1 ? d_dff
U12  Net-_M8-Pad1_ Net-_U12-Pad2_ Net-_U10-Pad5_ Net-_U12-Pad4_ d0 ? d_dff
U15  GND GND Net-_U13-Pad5_ GND Net-_U12-Pad2_ ? d_dff
v3  Net-_U10-Pad2_ GND pulse
U1  in plot_v1
M12  Net-_M10-Pad1_ Net-_M10-Pad1_ Net-_M12-Pad3_ Net-_M12-Pad3_ eSim_MOS_P
M14  Net-_M12-Pad3_ Net-_M10-Pad1_ Net-_M14-Pad3_ Net-_M14-Pad3_ eSim_MOS_P
M10  Net-_M10-Pad1_ d3 GND GND eSim_MOS_N
M11  Net-_M10-Pad1_ d2 GND GND eSim_MOS_N
M13  Net-_M10-Pad1_ d1 GND GND eSim_MOS_N
M15  Net-_M10-Pad1_ d0 GND GND eSim_MOS_N
U11  out plot_v1
U5  d3 plot_v1
U8  d2 plot_v1
U14  d1 plot_v1
U16  d0 plot_v1

.end
